## config/boards/shields/charybdis_mini/Kconfig.defconfig
```kconfig
if SHIELD_CHARYBDIS_MINI_LEFT || SHIELD_CHARYBDIS_MINI_RIGHT

config ZMK_KEYBOARD_NAME
    default "Charybdis Mini"

endif
```
